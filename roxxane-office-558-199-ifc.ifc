Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2020-03-26T16:21:56
Written by: Xbim File Processor version 4.0.0.0
Made in: Xbim version 4.0.0.0

# IfcDistributionPort (2)
Name | FlowDirection
 | SOURCE
 | SINK

# IfcFlowTerminal: LED
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: LED; Lamp lifetime: 1000; Socket: -; Light output ratio: 1; Luminous flux: 1500 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 1500 lm; LightEmitterNominalPower: 15.9 W; Spectrum: 380: 274091089269855, 385: 308037179221111, 390: 344865381406145, 395: 384682110047128, 400: 427586996581783, 405: 473672320705303, 410: 523022504581206, 415: 575713672133084, 420: 631813274443966, 425: 691379781471521, 430: 754462439541293, 435: 82110109341093, 440: 891326071107334, 445: 965158129226411, 450: 104260845595016, 455: 112367872867562, 460: 120836122286163, 465: 129663896847766, 470: 13884859502801, 475: 148386734803968, 480: 158273981279396, 485: 168505177519601, 490: 179074378206853, 495: 189974885734683, 500: 201199288369928, 505: 212739500124484, 510: 224586801993995, 515: 236731884237687, 520: 249164889391864, 525: 26187545572889, 530: 274852760893425, 535: 288085565468003, 540: 301562256240476, 545: 315270888966201, 550: 329199230437848, 555: 34333479969533, 560: 357664908227323, 565: 372176699034123, 570: 386857184439095, 575: 40169328255259, 580: 416671852307923, 585: 431779727003767, 590: 447003746301139, 595: 462330786635948, 600: 477747790019972, 605: 493241791213971, 610: 508799943266636, 615: 524409541422095, 620: 54005804540683, 625: 555733100114205, 630: 571422554711237, 635: 587114480198051, 640: 602797185455359, 645: 618459231819706, 650: 634089446229852, 655: 649676932990778, 660: 665211084204272, 665: 68068158891718, 670: 696078441039853, 675: 711391946088504, 680: 726612726805951, 685: 74173172771553, 690: 756740218663129, 695: 771629797401987, 700: 78639239127451, 705: 801020258044611, 710: 815505985933233, 715: 829842492908623, 720: 844023025281761, 725: 858041155655971, 730: 87189078027836, 735: 885566115839172, 740: 899061695763588, 745: 912372366038837, 750: 925493280617818, 755: 938419896438756, 760: 951147968098598, 765: 963673542216292, 770: 975992951520194, 775: 988102808692266, 780: 1; ColorTemperature: 2700 K; ColorRenderingIndex: 90

# IfcFlowTerminal: Roxxane Office Desk
In: Default Building
Type - Description: LED desk luminaire for the office, diffuser surface made of polycarbonate with aligned conical indentations for reducing glare and directing the light, luminaire head and arm made of aluminium, base plate made of steel (please order separately), each powder-coated, flexible supply cord from luminaire to converter, length 1,5 m, thanks to its touchless gesture control system the luminaire can be operated and dimmed intuitively, the high degree of manoeuvrability is achieved by means of precisely calibrated friction joints and the 270° rotatable 3D rod end, the maximum luminous flux adds up to 1500 lumens with a colour rendering index of CRI > 90 and complies with the recommendations for work surface lighting. Design: Rupert Kopp / Nimbus baseplate for Roxxane Office, white: 558-188, black: 558-189, silver: 558-190, dark bronze: 558-191, neon red: 558-192, table clamp: 008-768; PredefinedType: DIRECTIONSOURCE
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: ROXXANE NEW, Desk luminaire; Housing color: Not specified
General Information - Article number: 558-199; Article name: Roxxane Office Desk; Uld creation date: 26.03.2020 15:21:56
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 15.9 W
Pset_LightFixtureTypeCommon - NumberOfSources: 1; TotalWattage: 15.9 W; LightFixtureMountingType: Standing; LightFixturePlacingType: Floor; ManufacturersSpecificInformation: NIMBUS
