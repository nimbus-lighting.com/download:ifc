Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2022-02-02T09:08:17
Written by: Xbim File Processor version 4.0.0.0
Made in: Xbim version 4.0.0.0

# IfcDistributionPort (16)
Name | FlowDirection
8 x  | SOURCE
8 x  | SINK

# IfcFlowTerminal: LED (8)
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: LED; Lamp lifetime: 1000; Socket: -; Light output ratio: 0.998836; Luminous flux: 207.5 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 207.5 lm; LightEmitterNominalPower: 3.4 W; Spectrum: 380: 3690569940095, 385: 4417827229087, 390: 103848623026, 395: 2413660876001, 400: 1635812461327, 405: 4979578862755, 410: 12008388049112, 415: 19010183755416, 420: 43492384284535, 425: 92387686399588, 430: 170081055352913, 435: 269257868050557, 440: 40380870835791, 445: 53053129979791, 450: 541210894212732, 455: 426035362969713, 460: 319709451836581, 465: 266258975756854, 470: 226744256316502, 475: 207655744220688, 480: 216725827235634, 485: 242313897411951, 490: 279103409927536, 495: 328329280608539, 500: 378364184545817, 505: 420767841360709, 510: 462021280818343, 515: 499628684012278, 520: 53600339508975, 525: 569109151908192, 530: 601715266536285, 535: 639788059693626, 540: 661953558922068, 545: 700811371799149, 550: 726341656016481, 555: 763989655672423, 560: 798739391155653, 565: 823807606707386, 570: 857424658565251, 575: 884129681820959, 580: 923657720451389, 585: 931100423923485, 590: 9394705544887, 595: 955178378620732, 600: 987139827132279, 605: 994081671981375, 610: 979624106749581, 615: 966308697952284, 620: 932083700929844, 625: 905082811260578, 630: 85331256109502, 635: 812867663499088, 640: 772044579830947, 645: 723717028028327, 650: 667977465880293, 655: 605503400426768, 660: 557213452509668, 665: 512777944144936, 670: 456803100163102, 675: 410601427321495, 680: 369369935082491, 685: 329151369897868, 690: 292549661602736, 695: 26125055859854, 700: 235075104418585, 705: 201009171723973, 710: 171700611576055, 715: 153226696188552, 720: 134667771647789, 725: 105256592587452, 730: 9695868067302, 735: 84328451897198, 740: 75702721075612, 745: 61935410416435, 750: 55940253582514, 755: 47738579126093, 760: 40479643762502, 765: 36799415163306, 770: 29784469641817, 775: 28115994214981, 780: 32447745650972; ColorTemperature: 3000 K; ColorRenderingIndex: 92

# IfcFlowTerminal: LIGHTING PAD R 600
In: Default Building
Type - Description: Extremely effective sound-absorbing acoustic luminaire, 3 cable holders on top, tool-free adjustable, embossed front fleece, colour grey dawn, diameter 696 mm, sound absorption class B, closed plastic cover on the reverse, 8 Bartenbach lenses integrated in the front fleece, 100 % direct beam, narrow beam, CRI > 90, including converter and operating device, dimmable via DALI/switchDim, the dimming unit is capable for video conferencing, please order suspension set with supply cord separately according to your individual mounting situation (length 2 m: 555-713, length 4 m: 555-714). Front fleece available in further colours: far mountain, nightfall, soft moss, vineyard, white, yellow field, black ink.; PredefinedType: DIRECTIONSOURCE
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: LIGHTING PAD R, sound-absorbing acoustic luminaire; Housing color: White, Graphite, Blue, Green, Yellow, Red
General Information - Article number: 557-513; Article name: LIGHTING PAD R 600; Uld creation date: 02.02.2022 00:00:00
Mounting Information - Pendulum length: 100 cm
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 27.2 W
Pset_LightFixtureTypeCommon - NumberOfSources: 8; TotalWattage: 3.4 W; LightFixtureMountingType: Pendant; LightFixturePlacingType: Ceiling; ManufacturersSpecificInformation: NIMBUS
